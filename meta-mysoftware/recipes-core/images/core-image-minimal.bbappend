IMAGE_INSTALL:append = " bootinfo-server"
